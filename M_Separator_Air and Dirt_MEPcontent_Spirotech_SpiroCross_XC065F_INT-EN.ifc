Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC065F_INT-EN.ifc
Time: 2025-08-05T18:33:52+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (4)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_2152135_3
Port_2152135_4
Port_2152135_7
Port_2152135_8

# IfcValve: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC_INT-EN:XC065F, M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC_INT-EN:XC065F:2152135
In: F00
Type - Material: Color RGB 198-000-000, Color RGB 128-128-128, Color RGB 168-128-048, Color RAL 1003
Type - Other - Category: Pipe Accessories; Base Flange: 10 mm; Base Flange Radius: 38.05 mm; Bottom Geomtry Height: 95 mm; Brackets Height: 5 mm; Chamfer Radius: 31.8 mm; Cone Flange: 17 mm; Cone Flange Radius Bottom: 49 mm; Cone Flange Radius Top: 38.05 mm; Connection Diameter: 65 mm; Distance Between Brackets: 137 mm; DN: 65 mm; Drain Height: 100 mm; Drain Offset: 131 mm; Drain Radius: 16.85 mm; Family Name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC_INT-EN; Flange Body: 15 mm; Flange Body Radius: 92.5 mm; Flange Gasket: 3 mm; Flange Gasket Radius: 61 mm; Front Bracket Height: 60.0027 mm; Front Bracket Offset: 184.003 mm; Front Bracket Offset 2: 79.5 mm; h: 251 mm; H1: 465 mm; h2: 349 mm; h3: 100 mm; Inner Diameter Ring: 6 mm; OD: 76.1 mm; Outer Diameter Bracket: 26 mm; Type Value: 3; Upper Geometry Radius: 12 mm; Upper Side Height: 248 mm; Width: 230 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - D: 159 mm; H: 905 mm; L: 260 mm; LF: 350 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Low-loss Header with Deaerator & dirt separator - Steel - Flange DN065; Article Type: XC065F; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Low-loss Header with Deaerator & dirt separator - Steel - Flange DN065; EMCS Version: 4.0; ETIM Article Class: EC010260; Family Version: 12.05; GLN: 8717811000007; GTIN: 8717811015568; Manufacturer: Spirotech; Manufacturer Art. No.: XC065F; Manufacturer URL: https://www.spirotech.com/8717811015568; MEPcontent Class: SEPARATOR_AIR_AND_DIRT; Model: XC065F; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: XC065F; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0 m3/s; Nominal Flow Rate: 0.00556 m3/s; Pressure Stage: 16; Volume: 0.013 m3; Weight: 31 kg
Type - Mechanical - Flow - Pressure Drop: 2700 Pa
Type - Visibility - Flange: yes; Front Bracket: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: XC065F; sets with these values: 2
Other - Bottom Clearance Safe: 75 mm; Connection Length: 350 mm; Connectors Length: 350 mm; Connectors Length Safe: 395 mm; Family: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC_INT-EN; Family and Type: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC_INT-EN: XC065F; Length: 421 mm; Top Clearance Safe: 50 mm; Type: XC065F; Type Id: 2152100
Constraints - Actual Offset: 10 mm; Elevation from Level: 0 mm; Negative Offset: 10 mm
Dimensions - Area: 0.76736 m2; Maximum Size: 65 mm; Minimum Size: 65 mm; Volume: 0.0195466 m3
Graphics - Annotation Offset RL: 0 mm
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 m3/s; Flow In 2: 0 m3/s
Phasing - Phase Created: 3. New Construction
Visibility - Bottom Clearance: 75 mm; Counter Flange: no; Service Space: no; Top Clearance: 50 mm
Insulation - Insulation Thickness: 0 mm
